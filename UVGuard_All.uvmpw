<?xml version='1.0' encoding='utf-8'?>
<ProjectWorkspace><SchemaVersion>1.0</SchemaVersion><Header>UVGuard Application and Bootloader</Header><WorkspaceName>UVGuard</WorkspaceName><project><PathAndName>firmware\nrf5_sdk\examples\ble_peripheral\uvguard_secure\pca10040\s132\arm5_no_packs\UVGuard_Application_Unified.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive><NodeIsExpanded>1</NodeIsExpanded></project><project><PathAndName>firmware\nrf5_sdk\examples\dfu\uvguard_bootloader\pca10040_s132_ble\arm5_no_packs\UVGuard_Bootloader_Unified.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive><NodeIsExpanded>1</NodeIsExpanded></project></ProjectWorkspace>